# Keil uVision project STM32H750VB_Audio.uvprojx, settings and files
target Lua (6140001::V6.14.1::ARMCLANG)
  device: STM32H743IITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.6.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00100000) IROM2(0x08100000,0x00100000) XRAM(0x30000000,0x00048000) XRAM2(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: STM32H750VB_Audio +hex
  c flags: OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32H743xx
  c include: ..\CMSIS\Include;..\CMSIS\Include\Include;..\CMSIS\Source\arm;..\CMSIS\Source;..\STM32H7xx_Driver\Include;..\STM32H7xx_Driver\Source;..\FYYXXM_DRV\include;..\FYYXXM_DRV\source;..\FYYXXM_BSP\include;..\FYYXXM_BSP\source;..\User
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT5: ROM 0x8100000 size 0x100000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group User
    ./: main_app.c main_boot.c
  group CMSIS
    ../CMSIS/Include/: stm32h7xx_hal_conf.h
    ../CMSIS/Source/: stm32h7xx_hal_msp.c stm32h7xx_it.c system_stm32h7xx.c
    ../CMSIS/Source/arm/: startup_stm32h743xx.s
  group FYYXXM_BSP
    ../FYYXXM_BSP/include/: bsp.h
    ../FYYXXM_BSP/source/: bsp_mpu_config.c bsp_usart.c bsp_system_clock.c bsp_led.c bsp_boot.c bsp_cpu_flash.c
  group STM32H7xx/Driver
    ../STM32H7xx_Driver/Source/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_gpio.c stm32h7xx_hal_i2s.c stm32h7xx_hal_i2s_ex.c stm32h7xx_hal_iwdg.c stm32h7xx_hal_mdma.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_sai.c stm32h7xx_hal_sai_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_usart.c stm32h7xx_hal_usart_ex.c stm32h7xx_hal_timebase_tim.c stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_hal_sd.c stm32h7xx_hal_sd_ex.c stm32h7xx_ll_sdmmc.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_mmc.c stm32h7xx_hal_mmc_ex.c stm32h7xx_hal_adc.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_ll_delayblock.c stm32h7xx_hal_spi.c
